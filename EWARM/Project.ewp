# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: ..\Drivers\CMSIS\Include; ..\Drivers\FWlib\inc; ..\Users\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group (top)
    ../: readme.txt 常用定义.txt 测试数据包.txt 相关IO口.txt
  group Drivers/CMSIS
    ../Drivers/CMSIS/startup/: startup_stm32f4xx.s
  group Drivers/FWlib
    ../Drivers/FWlib/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Users
    ../Users/src/: Do_Com.c Do_DMA.c Do_Fun.c Do_GPIO.c Do_Queue.c Do_TIM.c Do_USART.c main.c stm32f4xx_it.c system_stm32f4xx.c
